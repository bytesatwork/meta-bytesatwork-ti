DUMMYPROVIDES_PACKAGES = "\
    bash \
    bash-src \
"
